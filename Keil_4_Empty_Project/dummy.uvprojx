# Keil uVision project dummy.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummy
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: .\src\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s
    ./src/CMSIS/: system_stm32f10x.c
  group Main
    ./src/: main.c
software components: CMSIS:CORE 5.0.1
